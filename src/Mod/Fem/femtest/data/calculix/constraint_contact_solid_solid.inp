** written by FreeCAD inp file writer for CalculiX,Abaqus meshes
** highest dimension mesh elements only.

** Nodes
*Node, NSET=Nall
1, 286, 25, -247
2, 286, 25, 253
3, 286, 0, -247
4, 286, 0, 253
5, 186, 25, -247
6, 186, 25, 253
7, 186, 0, -247
8, 186, 0, 253
9, 6.661338147751e-15, -42, -30
10, -6.661338147751e-15, -42, 30
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

** Volume elements
*Element, TYPE=C3D10, ELSET=Evolumes
1281, 32, 67, 33, 180, 1159, 1160, 587, 777, 2218, 778
1282, 23, 171, 57, 24, 752, 2219, 1173, 578, 753, 1141
1283, 270, 237, 211, 269, 1122, 2220, 2221, 1136, 1131, 2222
1284, 180, 220, 264, 256, 933, 2223, 2225, 2226, 2224, 1075
1285, 184, 230, 271, 216, 2227, 1112, 2229, 894, 2228, 2230
1286, 241, 265, 240, 201, 1080, 1079, 997, 2232, 2231, 2233
1287, 188, 56, 205, 249, 824, 846, 855, 2235, 2234, 2236
1288, 268, 215, 216, 183, 2237, 895, 2238, 2239, 892, 893
1289, 83, 241, 82, 48, 996, 995, 640, 1192, 2240, 1190
1290, 195, 243, 266, 244, 2241, 1085, 2242, 2243, 1006, 1086
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
** Define element set Eall
*ELSET, ELSET=Eall
Evolumes


***********************************************************
** Element sets for materials and FEM element type (solid, shell, beam, fluid)
*ELSET,ELSET=MechanicalMaterialSolid
Evolumes

***********************************************************
** constraints fixed node sets
** ConstraintFixed
*NSET,NSET=ConstraintFixed
1,
2,
3,
4,
5,
6,
7,
8,
9,
10,
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
***********************************************************
** constraints contact surface sets
** ConstraintContact
*SURFACE, NAME=DEPConstraintContact
1344,S4
1655,S1
1703,S3
1704,S4
1728,S3
1729,S4
1732,S3
1733,S1
1734,S3
1736,S4
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*SURFACE, NAME=INDConstraintContact
1283,S2
1286,S1
1289,S1
1290,S3
1292,S1
1294,S3
1295,S2
1298,S2
1300,S3
1303,S3
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
** Physical constants for SI(mm) unit system with Kelvins
*PHYSICAL CONSTANTS, ABSOLUTE ZERO=0, STEFAN BOLTZMANN=5.670374419e-11

***********************************************************
** Materials
** see information about units at file end
** FreeCAD material name: Steel-Generic
** MechanicalMaterial
*MATERIAL, NAME=MechanicalMaterial
*ELASTIC
200000,0.3

***********************************************************
** Sections
*SOLID SECTION, ELSET=MechanicalMaterialSolid, MATERIAL=MechanicalMaterial

***********************************************************
** Contact Constraints
** ConstraintContact
*CONTACT PAIR, INTERACTION=INTConstraintContact, TYPE=SURFACE TO SURFACE
DEPConstraintContact,INDConstraintContact
*SURFACE INTERACTION, NAME=INTConstraintContact
*SURFACE BEHAVIOR, PRESSURE-OVERCLOSURE=LINEAR
1000000

***********************************************************
** At least one step is needed to run an CalculiX analysis of FreeCAD
*STEP
*STATIC


***********************************************************
** Fixed Constraints
** ConstraintFixed
*BOUNDARY
ConstraintFixed,1
ConstraintFixed,2
ConstraintFixed,3


***********************************************************
** constraints pressure element face loads
** ConstraintPressure
*DLOAD
** ConstraintPressure: face load
1733,P4,100.0
1793,P1,100.0
1981,P4,100.0
2040,P1,100.0
2304,P2,100.0
2380,P3,100.0
2463,P2,100.0
2470,P2,100.0
2547,P1,100.0

***********************************************************
** Outputs --> frd file
*NODE FILE
U
*EL FILE
S, E
** outputs --> dat file
** reaction forces for Constraint fixed
*NODE PRINT, NSET=ConstraintFixed, TOTALS=ONLY
RF


***********************************************************
*END STEP

***********************************************************
** CalculiX Input file
**   written by    --> FreeCAD 0.21.0
**   written on    --> Tue Mar 28 06:51:00 2023
**   file name     --> constraint_contact_solid_solid.FCStd
**   analysis name --> Analysis
**
**
***********************************************************
**  About units:
**  See ccx manual, ccx does not know about any unit.
**  Golden rule: The user must make sure that the numbers they provide have consistent units.
**  The user is the FreeCAD calculix writer module ;-)
**
**  The unit system which is used at Guido Dhondt's company: mm, N, s, K
**  Since Length and Mass are connected by Force, if Length is mm the Mass is in t to get N
**  The following units are used to write to inp file:
**
**  Length: mm (this includes the mesh geometry)
**  Mass: t
**  TimeSpan: s
**  Temperature: K
**
**  This leads to:
**  Force: N
**  Pressure: N/mm^2 == MPa (Young's Modulus has unit Pressure)
**  Density: t/mm^3
**  Gravity: mm/s^2
**  Thermal conductivity: t*mm/K/s^3 == as W/m/K == kW/mm/K
**  Specific Heat: mm^2/s^2/K = J/kg/K == kJ/t/K
**
