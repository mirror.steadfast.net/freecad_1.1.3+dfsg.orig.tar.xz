** written by FreeCAD inp file writer for CalculiX,Abaqus meshes
** highest dimension mesh elements only.

** Nodes
*Node, NSET=Nall
1, -200, -100, 0
2, -200, -100, 10
3, 200, -100, 0
4, 200, -100, 10
5, 200, 100, 0
6, 200, 100, 10
7, -200, 100, 0
8, -200, 100, 10
9, 50, 0, 0
10, 50, 0, 10
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

** Volume elements
*Element, TYPE=C3D10, ELSET=Evolumes
4758, 5661, 5549, 1973, 8906, 7768, 8916, 8917, 8919, 8918, 8920
4759, 5515, 2117, 1827, 8908, 8922, 3556, 8921, 8924, 8923, 8925
4760, 5377, 1689, 1861, 8906, 8927, 4765, 8926, 8929, 8928, 8930
4761, 2311, 5999, 1850, 8900, 8932, 8931, 3372, 8934, 8933, 8935
4762, 5515, 5805, 2117, 8908, 7245, 8936, 8922, 8924, 8937, 8923
4763, 1850, 5999, 5538, 8900, 8931, 7061, 8938, 8935, 8933, 8939
4764, 5549, 1861, 1973, 8906, 8940, 4080, 8916, 8918, 8930, 8920
4765, 5595, 1990, 1907, 8902, 8942, 2450, 8941, 8944, 8943, 8945
4766, 5971, 2283, 5574, 8904, 8947, 8946, 7332, 8949, 8948, 8950
4767, 5749, 1852, 5540, 8907, 8952, 8951, 8685, 8954, 8953, 8955
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
** Define element set Eall
*ELSET, ELSET=Eall
Evolumes


***********************************************************
** Element sets for materials and FEM element type (solid, shell, beam, fluid)
*ELSET,ELSET=Material_linSolid
Evolumes

***********************************************************
** constraints fixed node sets
** ConstraintFixed
*NSET,NSET=ConstraintFixed
1,
2,
7,
8,
11,
250,
409,
410,
411,
412,
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
** Physical constants for SI(mm) unit system with Kelvins
*PHYSICAL CONSTANTS, ABSOLUTE ZERO=0, STEFAN BOLTZMANN=5.670374419e-11

***********************************************************
** Materials
** see information about units at file end
** FreeCAD material name: CalculiX-Steel
** Material_lin
*MATERIAL, NAME=Material_lin
*ELASTIC
210000,0.3
*EXPANSION, ZERO=0
0
*PLASTIC
240.0, 0.0
270.0, 0.025


***********************************************************
** Sections
*SOLID SECTION, ELSET=Material_linSolid, MATERIAL=Material_lin

***********************************************************
** At least one step is needed to run an CalculiX analysis of FreeCAD
*STEP, NLGEOM, INC=2000
*STATIC


***********************************************************
** Fixed Constraints
** ConstraintFixed
*BOUNDARY
ConstraintFixed,1
ConstraintFixed,2
ConstraintFixed,3


***********************************************************
** constraints pressure element face loads
** ConstraintPressure
*DLOAD
** Hole_Plate.Face2
4796,P3,-130.0
4799,P4,-130.0
4872,P4,-130.0
4875,P1,-130.0
5260,P3,-130.0
5261,P4,-130.0
5286,P3,-130.0
5287,P3,-130.0
5527,P1,-130.0
5528,P3,-130.0
5647,P1,-130.0
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
***********************************************************
** Outputs --> frd file
*NODE FILE
U
*EL FILE
S, E, PEEQ
** outputs --> dat file
** reaction forces for Constraint fixed
*NODE PRINT, NSET=ConstraintFixed, TOTALS=ONLY
RF

*OUTPUT, FREQUENCY=1
***********************************************************
*END STEP

***********************************************************
** CalculiX Input file
**   written by    --> FreeCAD 0.21.0
**   written on    --> Tue Mar 28 07:12:17 2023
**   file name     --> material_nonlinear.FCStd
**   analysis name --> Analysis
**
**
***********************************************************
**  About units:
**  See ccx manual, ccx does not know about any unit.
**  Golden rule: The user must make sure that the numbers they provide have consistent units.
**  The user is the FreeCAD calculix writer module ;-)
**
**  The unit system which is used at Guido Dhondt's company: mm, N, s, K
**  Since Length and Mass are connected by Force, if Length is mm the Mass is in t to get N
**  The following units are used to write to inp file:
**
**  Length: mm (this includes the mesh geometry)
**  Mass: t
**  TimeSpan: s
**  Temperature: K
**
**  This leads to:
**  Force: N
**  Pressure: N/mm^2 == MPa (Young's Modulus has unit Pressure)
**  Density: t/mm^3
**  Gravity: mm/s^2
**  Thermal conductivity: t*mm/K/s^3 == as W/m/K == kW/mm/K
**  Specific Heat: mm^2/s^2/K = J/kg/K == kJ/t/K
**
