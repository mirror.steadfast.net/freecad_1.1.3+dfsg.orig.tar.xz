** written by FreeCAD inp file writer for CalculiX,Abaqus meshes
** highest dimension mesh elements only.

** Nodes
*Node, NSET=Nall
1, 0, 0, 1000
2, 0, 0, 0
3, 0, 1000, 1000
4, 0, 1000, 0
5, 0, 0, 500
6, 0, 500, 1000
7, 0, 1000, 500
8, 0, 500, 0
9, 0, 500, 500
10, 0, 250, 750
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

** Volume elements
*Element, TYPE=C3D10, ELSET=Evolumes
657, 687, 305, 1043, 1045, 1050, 1048, 1049, 1052, 1051, 1053
658, 305, 878, 1043, 1045, 1055, 1054, 1048, 1051, 1056, 1053
659, 878, 496, 1043, 1045, 1058, 1057, 1054, 1056, 1059, 1053
660, 496, 687, 1043, 1045, 1060, 1049, 1057, 1059, 1052, 1053
661, 665, 283, 25, 474, 1061, 328, 711, 1063, 1062, 1064
662, 87, 855, 663, 281, 896, 1065, 1066, 331, 1067, 1068
663, 667, 285, 27, 477, 1069, 338, 721, 1071, 1070, 1072
664, 33, 292, 675, 865, 374, 1073, 755, 1075, 1074, 1076
665, 28, 669, 476, 286, 730, 1077, 1078, 349, 1079, 1080
666, 26, 477, 285, 667, 1081, 1070, 339, 720, 1071, 1069
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
** Define element set Eall
*ELSET, ELSET=Eall
Evolumes


***********************************************************
** Element sets for materials and FEM element type (solid, shell, beam, fluid)
*ELSET,ELSET=FemMaterialSolid
Evolumes

***********************************************************
** constraints fixed node sets
** ConstraintFixed
*NSET,NSET=ConstraintFixed
1,
2,
3,
4,
5,
6,
7,
8,
9,
10,
11,
12,
13,

** Physical constants for SI(mm) unit system with Kelvins
*PHYSICAL CONSTANTS, ABSOLUTE ZERO=0, STEFAN BOLTZMANN=5.670374419e-11

***********************************************************
** Materials
** see information about units at file end
** FreeCAD material name: CalculiX-Steel
** FemMaterial
*MATERIAL, NAME=FemMaterial
*ELASTIC
210000,0.3
*DENSITY
7.9E-09
*EXPANSION, ZERO=0
0

***********************************************************
** Sections
*SOLID SECTION, ELSET=FemMaterialSolid, MATERIAL=FemMaterial

***********************************************************
** At least one step is needed to run an CalculiX analysis of FreeCAD
*STEP, INC=2000
*STATIC


***********************************************************
** Fixed Constraints
** ConstraintFixed
*BOUNDARY
ConstraintFixed,1
ConstraintFixed,2
ConstraintFixed,3


***********************************************************
** Self weight Constraint
** ConstraintSelfWeight
*DLOAD
Eall,GRAV,9806.65,0,0,-1


***********************************************************
** Outputs --> frd file
*NODE FILE
U
*EL FILE
S, E
** outputs --> dat file
** reaction forces for Constraint fixed
*NODE PRINT, NSET=ConstraintFixed, TOTALS=ONLY
RF

*OUTPUT, FREQUENCY=1
***********************************************************
*END STEP

***********************************************************
** CalculiX Input file
**   written by    --> FreeCAD 0.19.21963 +19 (Git)
**   written on    --> Tue Jul 14 12:48:52 2020
**   file name     --> constraint_selfweight_cantilever.FCStd
**   analysis name --> Analysis
**
**
***********************************************************
**  About units:
**  See ccx manual, ccx does not know about any unit.
**  Golden rule: The user must make sure that the numbers they provide have consistent units.
**  The user is the FreeCAD calculix writer module ;-)
**
**  The unit system which is used at Guido Dhondt's company: mm, N, s, K
**  Since Length and Mass are connected by Force, if Length is mm the Mass is in t to get N
**  The following units are used to write to inp file:
**
**  Length: mm (this includes the mesh geometry)
**  Mass: t
**  TimeSpan: s
**  Temperature: K
**
**  This leads to:
**  Force: N
**  Pressure: N/mm^2 == MPa (Young's Modulus has unit Pressure)
**  Density: t/mm^3
**  Gravity: mm/s^2
**  Thermal conductivity: t*mm/K/s^3 == as W/m/K == kW/mm/K
**  Specific Heat: mm^2/s^2/K = J/kg/K == kJ/t/K
**
