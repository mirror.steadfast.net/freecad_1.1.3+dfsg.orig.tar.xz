** written by FreeCAD inp file writer for CalculiX,Abaqus meshes
** highest dimension mesh elements only.

** Nodes
*Node, NSET=Nall
1, 40, 0, 0
2, 40, 0, 10
3, 40, 10, 0
4, 40, 10, 10
5, 60, 0, 0
6, 60, 0, 10
7, 60, 10, 0
8, 60, 10, 10
9, 80, 0, 0
10, 80, 0, 10
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

** Volume elements
*Element, TYPE=C3D10, ELSET=Evolumes
819, 786, 1282, 751, 6254, 6319, 6318, 967, 6321, 6320, 6322
820, 1270, 1766, 1302, 6254, 6324, 6323, 1386, 6326, 6325, 6327
821, 643, 632, 785, 6257, 668, 6328, 6329, 6331, 6330, 6332
822, 1256, 6242, 6262, 6307, 6335, 6333, 6334, 6337, 6336, 6338
823, 6242, 1256, 6262, 6299, 6335, 6334, 6333, 6340, 6339, 6341
824, 645, 634, 6255, 6259, 705, 6342, 6343, 6345, 6344, 6346
825, 6242, 1256, 6299, 6307, 6335, 6339, 6340, 6336, 6337, 6347
826, 1036, 6252, 6266, 6314, 6350, 6348, 6349, 6352, 6351, 6353
827, 634, 645, 6255, 6303, 705, 6343, 6342, 6355, 6354, 6356
828, 6274, 6248, 6242, 6302, 6359, 6357, 6358, 6361, 6360, 6362
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
** Define element set Eall
*ELSET, ELSET=Eall
Evolumes


***********************************************************
** Element sets for materials and FEM element type (solid, shell, beam, fluid)
*ELSET,ELSET=FemMaterial1Solid
819,
820,
821,
822,
823,
824,
825,
826,
827,
828,
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*ELSET,ELSET=FemMaterial2Solid
6676,
6677,
6678,
6679,
6680,
6681,
6682,
6683,
6684,
6685,
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*ELSET,ELSET=FemMaterial3Solid
2285,
2286,
2287,
2288,
2289,
2290,
2291,
2292,
2293,
2294,
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
***********************************************************
** constraints fixed node sets
** ConstraintFixed
*NSET,NSET=ConstraintFixed
13,
14,
15,
16,
17,
18,
19,
20,
228,
229,
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
** Physical constants for SI(mm) unit system with Kelvins
*PHYSICAL CONSTANTS, ABSOLUTE ZERO=0, STEFAN BOLTZMANN=5.670374419e-11

***********************************************************
** Materials
** see information about units at file end
** FreeCAD material name: Concrete-Generic
** FemMaterial1
*MATERIAL, NAME=FemMaterial1
*ELASTIC
32000,0.17
*EXPANSION, ZERO=0
0
** FreeCAD material name: PLA
** FemMaterial2
*MATERIAL, NAME=FemMaterial2
*ELASTIC
3640,0.36
*EXPANSION, ZERO=0
0
** FreeCAD material name: Steel-Generic
** FemMaterial3
*MATERIAL, NAME=FemMaterial3
*ELASTIC
200000,0.3
*EXPANSION, ZERO=0
0

***********************************************************
** Sections
*SOLID SECTION, ELSET=FemMaterial1Solid, MATERIAL=FemMaterial1
*SOLID SECTION, ELSET=FemMaterial2Solid, MATERIAL=FemMaterial2
*SOLID SECTION, ELSET=FemMaterial3Solid, MATERIAL=FemMaterial3

***********************************************************
** At least one step is needed to run an CalculiX analysis of FreeCAD
*STEP, INC=2000
*STATIC


***********************************************************
** Fixed Constraints
** ConstraintFixed
*BOUNDARY
ConstraintFixed,1
ConstraintFixed,2
ConstraintFixed,3


***********************************************************
** constraints force node loads
** ConstraintForce
*CLOAD
** node loads on shape: Box1:Face6
17,3,-0
19,3,-0
22,3,-0
23,3,-0
406,3,-0
407,3,-0
408,3,-0
409,3,-0
410,3,-5.569444444448
411,3,-4.448173740406
412,3,-6.6928097972
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
** node loads on shape: Box2:Face6
2,3,-0
4,3,-0
22,3,-0
23,3,-0
43,3,-0
44,3,-0
45,3,-0
46,3,-0
47,3,-5.569444444642
48,3,-4.371164641927
49,3,-6.70304543074
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
** node loads on shape: Box3:Face6
2,3,-0
4,3,-0
6,3,-0
8,3,-0
43,3,-0
44,3,-0
45,3,-0
46,3,-0
47,3,-5.569444444642
48,3,-4.371164641927
49,3,-6.70304543074
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
** node loads on shape: Box4:Face6
6,3,-0
8,3,-0
10,3,-0
12,3,-0
155,3,-0
156,3,-0
157,3,-0
158,3,-0
159,3,-3.614848889167
160,3,-4.956060414833
161,3,-6.508969907333
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
** node loads on shape: Box5:Face6
10,3,-0
12,3,-0
14,3,-0
16,3,-0
191,3,-0
192,3,-0
193,3,-0
194,3,-0
195,3,-3.994984513341
196,3,-4.956060414705
197,3,-6.508969907333
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

***********************************************************
** Outputs --> frd file
*NODE FILE
U
*EL FILE
S, E
** outputs --> dat file
** reaction forces for Constraint fixed
*NODE PRINT, NSET=ConstraintFixed, TOTALS=ONLY
RF

*OUTPUT, FREQUENCY=1
***********************************************************
*END STEP

***********************************************************
** CalculiX Input file
**   written by    --> FreeCAD 0.21.0
**   written on    --> Tue Mar 28 05:32:06 2023
**   file name     --> material_multiple_bendingbeam_fiveboxes.FCStd
**   analysis name --> Analysis
**
**
***********************************************************
**  About units:
**  See ccx manual, ccx does not know about any unit.
**  Golden rule: The user must make sure that the numbers they provide have consistent units.
**  The user is the FreeCAD calculix writer module ;-)
**
**  The unit system which is used at Guido Dhondt's company: mm, N, s, K
**  Since Length and Mass are connected by Force, if Length is mm the Mass is in t to get N
**  The following units are used to write to inp file:
**
**  Length: mm (this includes the mesh geometry)
**  Mass: t
**  TimeSpan: s
**  Temperature: K
**
**  This leads to:
**  Force: N
**  Pressure: N/mm^2 == MPa (Young's Modulus has unit Pressure)
**  Density: t/mm^3
**  Gravity: mm/s^2
**  Thermal conductivity: t*mm/K/s^3 == as W/m/K == kW/mm/K
**  Specific Heat: mm^2/s^2/K = J/kg/K == kJ/t/K
**
