** written by FreeCAD inp file writer for CalculiX,Abaqus meshes
** highest dimension mesh elements only.

** Nodes
*Node, NSET=Nall
1, 100, 10, 0
2, 100, 0, 0
3, 80, 10, 0
4, 80, 0, 0
5, 60, 10, 0
6, 60, 0, 0
7, 40, 10, 0
8, 40, 0, 0
9, 20, 10, 0
10, 20, 0, 0
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

** Face elements
*Element, TYPE=S6, ELSET=Efaces
131, 13, 4, 17, 352, 357, 482
132, 14, 13, 127, 353, 483, 484
133, 15, 14, 128, 354, 485, 486
134, 14, 127, 128, 484, 487, 485
135, 16, 15, 129, 355, 488, 489
136, 15, 128, 129, 486, 490, 488
137, 3, 16, 130, 356, 491, 492
138, 26, 3, 130, 367, 492, 493
139, 16, 129, 130, 489, 494, 491
140, 17, 18, 131, 358, 495, 496
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
** Define element set Eall
*ELSET, ELSET=Eall
Efaces


***********************************************************
** Element sets for materials and FEM element type (solid, shell, beam, fluid)
*ELSET,ELSET=FemMaterial1ShellThickness
367,
368,
369,
370,
371,
372,
373,
374,
375,
376,
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*ELSET,ELSET=FemMaterial2ShellThickness
485,
486,
487,
488,
489,
490,
491,
492,
493,
494,
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*ELSET,ELSET=FemMaterial3ShellThickness
131,
132,
133,
134,
135,
136,
137,
138,
139,
140,
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
***********************************************************
** constraints fixed node sets
** ConstraintFixed
*NSET,NSET=ConstraintFixed
1,
2,
11,
12,
35,
36,
37,
38,
105,
106,
107,
108,
377,
378,
379,
380,
381,
457,
458,
459,
460,
461,

** Physical constants for SI(mm) unit system with Kelvins
*PHYSICAL CONSTANTS, ABSOLUTE ZERO=0, STEFAN BOLTZMANN=5.670374419e-11

***********************************************************
** Materials
** see information about units at file end
** FreeCAD material name: Concrete-Generic
** FemMaterial1
*MATERIAL, NAME=FemMaterial1
*ELASTIC
32000,0.17
*EXPANSION, ZERO=0
0
** FreeCAD material name: PLA
** FemMaterial2
*MATERIAL, NAME=FemMaterial2
*ELASTIC
3640,0.36
*EXPANSION, ZERO=0
0
** FreeCAD material name: Steel-Generic
** FemMaterial3
*MATERIAL, NAME=FemMaterial3
*ELASTIC
200000,0.3
*EXPANSION, ZERO=0
0

***********************************************************
** Sections
*SHELL SECTION, ELSET=FemMaterial1ShellThickness, MATERIAL=FemMaterial1, OFFSET=0
10
*SHELL SECTION, ELSET=FemMaterial2ShellThickness, MATERIAL=FemMaterial2, OFFSET=0
10
*SHELL SECTION, ELSET=FemMaterial3ShellThickness, MATERIAL=FemMaterial3, OFFSET=0
10

***********************************************************
** At least one step is needed to run an CalculiX analysis of FreeCAD
*STEP, INC=2000
*STATIC


***********************************************************
** Fixed Constraints
** ConstraintFixed
*BOUNDARY
ConstraintFixed,1
ConstraintFixed,2
ConstraintFixed,3
ConstraintFixed,4
ConstraintFixed,5
ConstraintFixed,6


***********************************************************
** constraints force node loads
** ConstraintForce
*CLOAD
** node loads on shape: Face1:Edge4
9,2,-33.33333333333
11,2,-33.33333333333
118,2,-66.66666666667
119,2,-66.66666666667
120,2,-66.66666666667
121,2,-66.66666666667
122,2,-66.66666666667
123,2,-66.66666666667
124,2,-66.66666666667
125,2,-66.66666666667
126,2,-66.66666666667
472,2,-133.3333333333
473,2,-133.3333333333
474,2,-133.3333333333
475,2,-133.3333333333
476,2,-133.3333333333
477,2,-133.3333333333
478,2,-133.3333333333
479,2,-133.3333333333
480,2,-133.3333333333
481,2,-133.3333333333

** node loads on shape: Face2:Edge4
7,2,-33.33333333333
9,2,-33.33333333333
96,2,-66.66666666667
97,2,-66.66666666667
98,2,-66.66666666667
99,2,-66.66666666667
100,2,-66.66666666667
101,2,-66.66666666667
102,2,-66.66666666667
103,2,-66.66666666667
104,2,-66.66666666667
447,2,-133.3333333333
448,2,-133.3333333333
449,2,-133.3333333333
450,2,-133.3333333333
451,2,-133.3333333333
452,2,-133.3333333333
453,2,-133.3333333333
454,2,-133.3333333333
455,2,-133.3333333333
456,2,-133.3333333333

** node loads on shape: Face3:Edge4
5,2,-33.33333333333
7,2,-33.33333333333
74,2,-66.66666666667
75,2,-66.66666666667
76,2,-66.66666666667
77,2,-66.66666666667
78,2,-66.66666666667
79,2,-66.66666666667
80,2,-66.66666666667
81,2,-66.66666666667
82,2,-66.66666666667
422,2,-133.3333333333
423,2,-133.3333333333
424,2,-133.3333333333
425,2,-133.3333333333
426,2,-133.3333333333
427,2,-133.3333333333
428,2,-133.3333333333
429,2,-133.3333333333
430,2,-133.3333333333
431,2,-133.3333333333

** node loads on shape: Face4:Edge4
3,2,-33.33333333333
5,2,-33.33333333333
52,2,-66.66666666667
53,2,-66.66666666667
54,2,-66.66666666667
55,2,-66.66666666667
56,2,-66.66666666667
57,2,-66.66666666667
58,2,-66.66666666667
59,2,-66.66666666667
60,2,-66.66666666667
397,2,-133.3333333333
398,2,-133.3333333333
399,2,-133.3333333333
400,2,-133.3333333333
401,2,-133.3333333333
402,2,-133.3333333333
403,2,-133.3333333333
404,2,-133.3333333333
405,2,-133.3333333333
406,2,-133.3333333333

** node loads on shape: Face5:Edge4
1,2,-33.33333333333
3,2,-33.33333333333
26,2,-66.66666666667
27,2,-66.66666666667
28,2,-66.66666666667
29,2,-66.66666666667
30,2,-66.66666666667
31,2,-66.66666666667
32,2,-66.66666666667
33,2,-66.66666666667
34,2,-66.66666666667
367,2,-133.3333333333
368,2,-133.3333333333
369,2,-133.3333333333
370,2,-133.3333333333
371,2,-133.3333333333
372,2,-133.3333333333
373,2,-133.3333333333
374,2,-133.3333333333
375,2,-133.3333333333
376,2,-133.3333333333


***********************************************************
** Outputs --> frd file
*NODE FILE, OUTPUT=3d
U
*EL FILE
S, E
** outputs --> dat file
** reaction forces for Constraint fixed
*NODE PRINT, NSET=ConstraintFixed, TOTALS=ONLY
RF

*OUTPUT, FREQUENCY=1
***********************************************************
*END STEP

***********************************************************
** CalculiX Input file
**   written by    --> FreeCAD 0.21.0
**   written on    --> Tue Mar 28 05:33:12 2023
**   file name     --> material_multiple_bendingbeam_fivefaces.FCStd
**   analysis name --> Analysis
**
**
***********************************************************
**  About units:
**  See ccx manual, ccx does not know about any unit.
**  Golden rule: The user must make sure that the numbers they provide have consistent units.
**  The user is the FreeCAD calculix writer module ;-)
**
**  The unit system which is used at Guido Dhondt's company: mm, N, s, K
**  Since Length and Mass are connected by Force, if Length is mm the Mass is in t to get N
**  The following units are used to write to inp file:
**
**  Length: mm (this includes the mesh geometry)
**  Mass: t
**  TimeSpan: s
**  Temperature: K
**
**  This leads to:
**  Force: N
**  Pressure: N/mm^2 == MPa (Young's Modulus has unit Pressure)
**  Density: t/mm^3
**  Gravity: mm/s^2
**  Thermal conductivity: t*mm/K/s^3 == as W/m/K == kW/mm/K
**  Specific Heat: mm^2/s^2/K = J/kg/K == kJ/t/K
**
