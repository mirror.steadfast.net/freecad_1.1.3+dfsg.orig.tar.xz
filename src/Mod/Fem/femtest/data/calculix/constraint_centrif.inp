** written by FreeCAD inp file writer for CalculiX,Abaqus meshes
** highest dimension mesh elements only.

** Nodes
*Node, NSET=Nall
1, 102.5, -2.5e-14, 10
2, 102.5, -2.5e-14, 0
3, 3, -1e-15, 10
4, -4.999999999999, 97.37171047075, 10
5, -4.999999999999, -97.37171047075, 10
6, 97.5, -2.4e-14, 10
7, 4.999999999999, 97.37171047075, 10
8, 4.999999999999, -97.37171047075, 10
9, 3, -1e-15, 0
10, -4.999999999999, -97.37171047075, 0
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

** Volume elements
*Element, TYPE=C3D4, ELSET=Evolumes
7737, 1784, 1740, 2236, 2250
7738, 2223, 1790, 1746, 2243
7739, 2246, 1799, 1756, 2237
7740, 2229, 1777, 1734, 2246
7741, 2012, 1740, 1748, 1784
7742, 1784, 2236, 1740, 1748
7743, 1784, 2236, 2032, 1791
7744, 1784, 2032, 2236, 1748
7745, 2032, 1748, 1784, 2012
7746, 2032, 1735, 1778, 2236
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
** Define element set Eall
*ELSET, ELSET=Eall
Evolumes


***********************************************************
** Element sets for materials and FEM element type (solid, shell, beam, fluid)
*ELSET,ELSET=Steel_ScottySolid
7737,
7738,
7739,
7740,
7741,
7742,
7743,
7744,
7745,
7746,
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*ELSET,ELSET=Steel_StdSolid
11594,
11595,
11596,
11597,
11598,
11599,
11600,
11601,
11602,
11603,
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
***********************************************************
** constraints centrif element sets
** ConstraintCentrif
*ELSET,ELSET=ConstraintCentrif
Evolumes

***********************************************************
** constraints fixed node sets
** ConstraintFixed
*NSET,NSET=ConstraintFixed
3,
9,
17,
23,
286,
287,
288,
482,
483,
484,
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
** Physical constants for SI(mm) unit system with Kelvins
*PHYSICAL CONSTANTS, ABSOLUTE ZERO=0, STEFAN BOLTZMANN=5.670374419e-11

***********************************************************
** Materials
** see information about units at file end
** FreeCAD material name: Steel_Scotty
** Steel_Scotty
*MATERIAL, NAME=Steel_Scotty
*ELASTIC
210000,0.3
*DENSITY
4E-09
** FreeCAD material name: Steel_Std
** Steel_Std
*MATERIAL, NAME=Steel_Std
*ELASTIC
210000,0.3
*DENSITY
8E-09

***********************************************************
** Sections
*SOLID SECTION, ELSET=Steel_ScottySolid, MATERIAL=Steel_Scotty
*SOLID SECTION, ELSET=Steel_StdSolid, MATERIAL=Steel_Std

***********************************************************
** At least one step is needed to run an CalculiX analysis of FreeCAD
*STEP
*STATIC


***********************************************************
** Fixed Constraints
** ConstraintFixed
*BOUNDARY
ConstraintFixed,1
ConstraintFixed,2
ConstraintFixed,3


***********************************************************
** Centrif Constraints
** ConstraintCentrif
*DLOAD
ConstraintCentrif,CENTRIF,394784.1760436,0,0,0,0,0,1


***********************************************************
** Outputs --> frd file
*NODE FILE
U
*EL FILE
S, E
** outputs --> dat file
** reaction forces for Constraint fixed
*NODE PRINT, NSET=ConstraintFixed, TOTALS=ONLY
RF


***********************************************************
*END STEP

***********************************************************
** CalculiX Input file
**   written by    --> FreeCAD 0.20.25188 (Git)
**   written on    --> Mon Jul  5 15:41:32 2021
**   file name     --> centrif.FCStd
**   analysis name --> Analysis
**
**
***********************************************************
**  About units:
**  See ccx manual, ccx does not know about any unit.
**  Golden rule: The user must make sure that the numbers they provide have consistent units.
**  The user is the FreeCAD calculix writer module ;-)
**
**  The unit system which is used at Guido Dhondt's company: mm, N, s, K
**  Since Length and Mass are connected by Force, if Length is mm the Mass is in t to get N
**  The following units are used to write to inp file:
**
**  Length: mm (this includes the mesh geometry)
**  Mass: t
**  TimeSpan: s
**  Temperature: K
**
**  This leads to:
**  Force: N
**  Pressure: N/mm^2 == MPa (Young's Modulus has unit Pressure)
**  Density: t/mm^3
**  Gravity: mm/s^2
**  Thermal conductivity: t*mm/K/s^3 == as W/m/K == kW/mm/K
**  Specific Heat: mm^2/s^2/K = J/kg/K == kJ/t/K
**
