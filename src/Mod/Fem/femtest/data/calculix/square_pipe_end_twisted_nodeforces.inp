** written by FreeCAD inp file writer for CalculiX,Abaqus meshes
** highest dimension mesh elements only.

** Nodes
*Node, NSET=Nall
1, -142.5, 142.5, 0
2, -142.5, -142.5, 0
3, -142.5, 142.5, 1000
4, -142.5, -142.5, 1000
5, -142.5, 95, 0
6, -142.5, 47.5, 0
7, -142.5, 0, 0
8, -142.5, -47.5, 0
9, -142.5, -95, 0
10, -142.5, 142.5, 50
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

** Face elements
*Element, TYPE=S6, ELSET=Efaces
1, 125, 112, 49, 724, 565, 566
2, 125, 119, 112, 742, 723, 724
3, 125, 120, 119, 744, 741, 742
4, 125, 126, 120, 755, 745, 744
5, 125, 50, 126, 568, 569, 755
6, 125, 49, 50, 566, 564, 568
7, 120, 117, 119, 737, 736, 741
8, 120, 118, 117, 738, 735, 737
9, 120, 123, 118, 743, 740, 738
10, 120, 126, 123, 745, 751, 743
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
** Define element set Eall
*ELSET, ELSET=Eall
Efaces


***********************************************************
** Element sets for materials and FEM element type (solid, shell, beam, fluid)
*ELSET,ELSET=FemMaterialShellThickness
Efaces

***********************************************************
** constraints fixed node sets
** ConstraintFixed
*NSET,NSET=ConstraintFixed
3,
4,
29,
30,
31,
32,
33,
130,
136,
137,
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
** Physical constants for SI(mm) unit system with Kelvins
*PHYSICAL CONSTANTS, ABSOLUTE ZERO=0, STEFAN BOLTZMANN=5.670374419e-11

***********************************************************
** Materials
** see information about units at file end
** FreeCAD material name: Steel-Generic
** FemMaterial
*MATERIAL, NAME=FemMaterial
*ELASTIC
200000,0.3
*EXPANSION, ZERO=0
0

***********************************************************
** Sections
*SHELL SECTION, ELSET=FemMaterialShellThickness, MATERIAL=FemMaterial, OFFSET=0
15

***********************************************************
** At least one step is needed to run an CalculiX analysis of FreeCAD
*STEP, INC=2000
*STATIC


***********************************************************
** Fixed Constraints
** ConstraintFixed
*BOUNDARY
ConstraintFixed,1
ConstraintFixed,2
ConstraintFixed,3
ConstraintFixed,4
ConstraintFixed,5
ConstraintFixed,6


***********************************************************
** constraints force node loads
** ConstraintForce1
*CLOAD
** node load on shape: Forces:Vertex1
1,1,-2777.78

** node load on shape: Forces:Vertex14
236,1,-2777.78


** ConstraintForce2
*CLOAD
** node load on shape: Forces:Vertex2
2,1,2777.78

** node load on shape: Forces:Vertex8
129,1,2777.78


** ConstraintForce3
*CLOAD
** node load on shape: Forces:Vertex20
343,1,-5555.556

** node load on shape: Forces:Vertex21
344,1,-5555.556

** node load on shape: Forces:Vertex22
345,1,-5555.556

** node load on shape: Forces:Vertex23
346,1,-5555.556

** node load on shape: Forces:Vertex24
347,1,-5555.556


** ConstraintForce4
*CLOAD
** node load on shape: Forces:Vertex9
131,1,5555.556

** node load on shape: Forces:Vertex10
132,1,5555.556

** node load on shape: Forces:Vertex11
133,1,5555.556

** node load on shape: Forces:Vertex12
134,1,5555.556

** node load on shape: Forces:Vertex13
135,1,5555.556


** ConstraintForce5
*CLOAD
** node load on shape: Forces:Vertex43
1376,1,-11111.11166667

** node load on shape: Forces:Vertex44
1378,1,-11111.11166667

** node load on shape: Forces:Vertex45
1380,1,-11111.11166667

** node load on shape: Forces:Vertex46
1383,1,-11111.11166667

** node load on shape: Forces:Vertex47
1386,1,-11111.11166667

** node load on shape: Forces:Vertex48
1390,1,-11111.11166667


** ConstraintForce6
*CLOAD
** node load on shape: Forces:Vertex31
758,1,11111.11166667

** node load on shape: Forces:Vertex32
762,1,11111.11166667

** node load on shape: Forces:Vertex33
764,1,11111.11166667

** node load on shape: Forces:Vertex34
766,1,11111.11166667

** node load on shape: Forces:Vertex35
769,1,11111.11166667

** node load on shape: Forces:Vertex36
772,1,11111.11166667


** ConstraintForce7
*CLOAD
** node load on shape: Forces:Vertex1
1,2,-2777.78

** node load on shape: Forces:Vertex2
2,2,-2777.78


** ConstraintForce8
*CLOAD
** node load on shape: Forces:Vertex8
129,2,2777.78

** node load on shape: Forces:Vertex14
236,2,2777.78


** ConstraintForce9
*CLOAD
** node load on shape: Forces:Vertex3
5,2,-5555.556

** node load on shape: Forces:Vertex4
6,2,-5555.556

** node load on shape: Forces:Vertex5
7,2,-5555.556

** node load on shape: Forces:Vertex6
8,2,-5555.556

** node load on shape: Forces:Vertex7
9,2,-5555.556


** ConstraintForce10
*CLOAD
** node load on shape: Forces:Vertex15
238,2,5555.556

** node load on shape: Forces:Vertex16
239,2,5555.556

** node load on shape: Forces:Vertex17
240,2,5555.556

** node load on shape: Forces:Vertex18
241,2,5555.556

** node load on shape: Forces:Vertex19
242,2,5555.556


** ConstraintForce11
*CLOAD
** node load on shape: Forces:Vertex25
429,2,-11111.11166667

** node load on shape: Forces:Vertex26
431,2,-11111.11166667

** node load on shape: Forces:Vertex27
437,2,-11111.11166667

** node load on shape: Forces:Vertex28
440,2,-11111.11166667

** node load on shape: Forces:Vertex29
443,2,-11111.11166667

** node load on shape: Forces:Vertex30
446,2,-11111.11166667


** ConstraintForce12
*CLOAD
** node load on shape: Forces:Vertex37
1067,2,11111.11166667

** node load on shape: Forces:Vertex38
1071,2,11111.11166667

** node load on shape: Forces:Vertex39
1073,2,11111.11166667

** node load on shape: Forces:Vertex40
1075,2,11111.11166667

** node load on shape: Forces:Vertex41
1078,2,11111.11166667

** node load on shape: Forces:Vertex42
1081,2,11111.11166667


***********************************************************
** Outputs --> frd file
*NODE FILE, OUTPUT=3d
U
*EL FILE
S, E
** outputs --> dat file
** reaction forces for Constraint fixed
*NODE PRINT, NSET=ConstraintFixed, TOTALS=ONLY
RF

*OUTPUT, FREQUENCY=1
***********************************************************
*END STEP

***********************************************************
** CalculiX Input file
**   written by    --> FreeCAD 0.21.0
**   written on    --> Tue Mar 28 05:36:19 2023
**   file name     --> square_pipe_end_twisted_nodeforces.FCStd
**   analysis name --> Analysis
**
**
***********************************************************
**  About units:
**  See ccx manual, ccx does not know about any unit.
**  Golden rule: The user must make sure that the numbers they provide have consistent units.
**  The user is the FreeCAD calculix writer module ;-)
**
**  The unit system which is used at Guido Dhondt's company: mm, N, s, K
**  Since Length and Mass are connected by Force, if Length is mm the Mass is in t to get N
**  The following units are used to write to inp file:
**
**  Length: mm (this includes the mesh geometry)
**  Mass: t
**  TimeSpan: s
**  Temperature: K
**
**  This leads to:
**  Force: N
**  Pressure: N/mm^2 == MPa (Young's Modulus has unit Pressure)
**  Density: t/mm^3
**  Gravity: mm/s^2
**  Thermal conductivity: t*mm/K/s^3 == as W/m/K == kW/mm/K
**  Specific Heat: mm^2/s^2/K = J/kg/K == kJ/t/K
**
