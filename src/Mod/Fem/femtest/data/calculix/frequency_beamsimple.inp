** written by FreeCAD inp file writer for CalculiX,Abaqus meshes
** highest dimension mesh elements only.

** Nodes
*Node, NSET=Nall
1, 0, 0, 0
2, 0, 100, 0
3, 3000, 0, 0
4, 3000, 100, 0
5, 0, 25, 0
6, 0, 50, 0
7, 0, 75, 0
8, 0, 12.5, 0
9, 0, 37.5, 0
10, 0, 62.5, 0
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

** Volume elements
*Element, TYPE=C3D10, ELSET=Evolumes
4057, 5327, 1176, 7141, 7160, 7268, 7266, 7267, 7270, 7269, 7271
4058, 1176, 3032, 7141, 7160, 7273, 7272, 7266, 7269, 7274, 7271
4059, 7143, 1115, 3031, 7162, 7277, 7275, 7276, 7279, 7278, 7280
4060, 5326, 1115, 7143, 7162, 7282, 7277, 7281, 7283, 7278, 7279
4061, 1173, 3030, 7140, 7163, 7286, 7284, 7285, 7288, 7287, 7289
4062, 5325, 1173, 7140, 7163, 7291, 7285, 7290, 7292, 7288, 7289
4063, 2767, 5208, 4888, 7225, 7294, 6840, 7293, 7296, 7295, 7297
4064, 1159, 5208, 2767, 7225, 7299, 7294, 7298, 7300, 7295, 7296
4065, 4927, 2626, 7207, 7257, 7303, 7301, 7302, 7305, 7304, 7306
4066, 7128, 4942, 2645, 7174, 7309, 7307, 7308, 7311, 7310, 7312
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
** Define element set Eall
*ELSET, ELSET=Eall
Evolumes


***********************************************************
** Element sets for materials and FEM element type (solid, shell, beam, fluid)
*ELSET,ELSET=MechanicalMaterialSolid
Evolumes

***********************************************************
** constraints displacement node sets
** Fix_XYZ
*NSET,NSET=Fix_XYZ
1,
2,
5,
6,
7,
8,
9,
10,
11,
** Fix_YZ
*NSET,NSET=Fix_YZ
3,
4,
12,
13,
14,
15,
16,
17,
18,

** Physical constants for SI(mm) unit system with Kelvins
*PHYSICAL CONSTANTS, ABSOLUTE ZERO=0, STEFAN BOLTZMANN=5.670374419e-11

***********************************************************
** Materials
** see information about units at file end
** FreeCAD material name: Steel-Generic
** MechanicalMaterial
*MATERIAL, NAME=MechanicalMaterial
*ELASTIC
200000,0.3
*DENSITY
7.9E-09

***********************************************************
** Sections
*SOLID SECTION, ELSET=MechanicalMaterialSolid, MATERIAL=MechanicalMaterial

***********************************************************
** At least one step is needed to run an CalculiX analysis of FreeCAD
*STEP
*FREQUENCY
10,0.01,1000000.0


***********************************************************
** Displacement constraint applied
** Fix_XYZ
*BOUNDARY
Fix_XYZ,1,1,0.0
Fix_XYZ,2,2,0.0
Fix_XYZ,3,3,0.0
** Fix_YZ
*BOUNDARY
Fix_YZ,2,2,0.0
Fix_YZ,3,3,0.0


***********************************************************
** Outputs --> frd file
*NODE FILE
U
*EL FILE
S, E
** outputs --> dat file
** reaction forces for Constraint displacement constraining translation
*NODE PRINT, NSET=Fix_XYZ, TOTALS=ONLY
RF
*NODE PRINT, NSET=Fix_YZ, TOTALS=ONLY
RF

*OUTPUT, FREQUENCY=1
***********************************************************
*END STEP

***********************************************************
** CalculiX Input file
**   written by    --> FreeCAD 0.20.25028 (Git)
**   written on    --> Tue Jun  8 22:18:58 2021
**   file name     --> test.FCStd
**   analysis name --> Analysis
**
**
***********************************************************
**  About units:
**  See ccx manual, ccx does not know about any unit.
**  Golden rule: The user must make sure that the numbers they provide have consistent units.
**  The user is the FreeCAD calculix writer module ;-)
**
**  The unit system which is used at Guido Dhondt's company: mm, N, s, K
**  Since Length and Mass are connected by Force, if Length is mm the Mass is in t to get N
**  The following units are used to write to inp file:
**
**  Length: mm (this includes the mesh geometry)
**  Mass: t
**  TimeSpan: s
**  Temperature: K
**
**  This leads to:
**  Force: N
**  Pressure: N/mm^2 == MPa (Young's Modulus has unit Pressure)
**  Density: t/mm^3
**  Gravity: mm/s^2
**  Thermal conductivity: t*mm/K/s^3 == as W/m/K == kW/mm/K
**  Specific Heat: mm^2/s^2/K = J/kg/K == kJ/t/K
**
