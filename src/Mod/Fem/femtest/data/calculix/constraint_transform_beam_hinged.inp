** written by FreeCAD inp file writer for CalculiX,Abaqus meshes
** highest dimension mesh elements only.

** Nodes
*Node, NSET=Nall
1, 200, 0, 0
2, 200, 10, 0
3, 0, 0, 0
4, 184, 0, 10
5, 16, 0, 10
6, 0, 10, 0
7, 184, 10, 10
8, 16, 10, 10
9, 200, 5, 0
10, 200, 2.5, 0
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

** Volume elements
*Element, TYPE=C3D10, ELSET=Evolumes
975, 1261, 660, 636, 114, 1612, 952, 1611, 1614, 1613, 1615
976, 98, 1259, 635, 659, 1618, 1616, 1617, 1620, 1619, 945
977, 636, 1231, 1261, 114, 1621, 1534, 1611, 1615, 1622, 1614
978, 98, 635, 1259, 1230, 1617, 1616, 1618, 1624, 1623, 1527
979, 1231, 1262, 114, 661, 1533, 1625, 1622, 1627, 1626, 1628
980, 114, 636, 1231, 661, 1615, 1621, 1622, 1628, 951, 1627
981, 635, 1260, 98, 662, 1630, 1629, 1617, 944, 1631, 1632
982, 98, 635, 1230, 1260, 1617, 1623, 1624, 1629, 1630, 1526
983, 1261, 114, 1231, 1262, 1614, 1622, 1534, 1326, 1625, 1533
984, 114, 660, 636, 661, 1613, 952, 1615, 1628, 736, 951
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
** Define element set Eall
*ELSET, ELSET=Eall
Evolumes


***********************************************************
** Element sets for materials and FEM element type (solid, shell, beam, fluid)
*ELSET,ELSET=FemMaterialSolid
Evolumes

***********************************************************
** constraints displacement node sets
** FemConstraintDisplacement
*NSET,NSET=FemConstraintDisplacement
4,
5,
7,
8,
69,
70,
71,
72,
73,
74,
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
***********************************************************
** constraints transform node sets
** FemConstraintTransform1
*NSET,NSET=CylinFemConstraintTransform1
5,
8,
82,
83,
84,
85,
86,
87,
88,
89,
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** FemConstraintTransform2
*NSET,NSET=CylinFemConstraintTransform2
4,
7,
69,
70,
71,
72,
73,
74,
75,
76,
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
** Physical constants for SI(mm) unit system with Kelvins
*PHYSICAL CONSTANTS, ABSOLUTE ZERO=0, STEFAN BOLTZMANN=5.670374419e-11

***********************************************************
** Materials
** see information about units at file end
** FreeCAD material name: CalculiX-Steel
** FemMaterial
*MATERIAL, NAME=FemMaterial
*ELASTIC
210000,0.3
*EXPANSION, ZERO=0
0

***********************************************************
** Sections
*SOLID SECTION, ELSET=FemMaterialSolid, MATERIAL=FemMaterial

***********************************************************
** Transform Constraints
** FemConstraintTransform1
*TRANSFORM, NSET=CylinFemConstraintTransform1, TYPE=C
10,5,10,10,6,10
** FemConstraintTransform2
*TRANSFORM, NSET=CylinFemConstraintTransform2, TYPE=C
190,5,10,190,6,10

***********************************************************
** At least one step is needed to run an CalculiX analysis of FreeCAD
*STEP, INC=2000
*STATIC


***********************************************************
** Displacement constraint applied
** FemConstraintDisplacement
*BOUNDARY
FemConstraintDisplacement,1,1,0.0


***********************************************************
** constraints pressure element face loads
** FemConstraintPressure
*DLOAD
** CompoundFilter.Face8
1384,P3,10.0
1394,P2,10.0
1397,P2,10.0
1399,P1,10.0
1400,P1,10.0
1402,P2,10.0
1404,P2,10.0
1415,P4,10.0
1418,P1,10.0
1419,P2,10.0
1423,P2,10.0
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
***********************************************************
** Outputs --> frd file
*NODE FILE
U
*EL FILE
S, E
** outputs --> dat file
** reaction forces for Constraint displacement constraining translation
*NODE PRINT, NSET=FemConstraintDisplacement, TOTALS=ONLY
RF

*OUTPUT, FREQUENCY=1
***********************************************************
*END STEP

***********************************************************
** CalculiX Input file
**   written by    --> FreeCAD 0.21.0
**   written on    --> Tue Mar 28 06:46:40 2023
**   file name     --> constraint_transform_beam_hinged.FCStd
**   analysis name --> Analysis
**
**
***********************************************************
**  About units:
**  See ccx manual, ccx does not know about any unit.
**  Golden rule: The user must make sure that the numbers they provide have consistent units.
**  The user is the FreeCAD calculix writer module ;-)
**
**  The unit system which is used at Guido Dhondt's company: mm, N, s, K
**  Since Length and Mass are connected by Force, if Length is mm the Mass is in t to get N
**  The following units are used to write to inp file:
**
**  Length: mm (this includes the mesh geometry)
**  Mass: t
**  TimeSpan: s
**  Temperature: K
**
**  This leads to:
**  Force: N
**  Pressure: N/mm^2 == MPa (Young's Modulus has unit Pressure)
**  Density: t/mm^3
**  Gravity: mm/s^2
**  Thermal conductivity: t*mm/K/s^3 == as W/m/K == kW/mm/K
**  Specific Heat: mm^2/s^2/K = J/kg/K == kJ/t/K
**
