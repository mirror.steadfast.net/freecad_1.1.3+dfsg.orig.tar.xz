** written by FreeCAD inp file writer for CalculiX,Abaqus meshes
** highest dimension mesh elements only.

** Nodes
*Node, NSET=Nall
1, -2.22e-13, 0, 1000
2, 4.460492503132e-17, 0, 0
3, 4.460492503132e-17, 1000, 0
4, -2.22e-13, 1000, 1000
5, 8000, 0, 1000
6, 8000, 0, 1.818989403546e-12
7, 8000, 1000, 1.818989403546e-12
8, 8000, 1000, 1000
9, -1.664888487687e-13, 0, 750
10, -1.109776975375e-13, 0, 500
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

** Volume elements
*Element, TYPE=C3D20, ELSET=Evolumes
1, 1, 10, 95, 19, 61, 105, 222, 192, 9, 93, 94, 20, 104, 220, 221,
193, 62, 103, 219, 190
2, 10, 2, 13, 95, 105, 34, 134, 222, 11, 12, 96, 93, 106, 133, 223,
220, 103, 33, 132, 219
3, 19, 95, 16, 4, 192, 222, 163, 79, 94, 97, 17, 18, 221, 224, 164,
191, 190, 219, 161, 78
4, 95, 13, 3, 16, 222, 134, 64, 163, 96, 14, 15, 97, 223, 135, 162,
224, 219, 132, 63, 161
5, 61, 105, 222, 192, 59, 109, 228, 196, 104, 220, 221, 193, 108, 226, 227,
197, 60, 107, 225, 194
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
** Define element set Eall
*ELSET, ELSET=Eall
Evolumes


***********************************************************
** Element sets for materials and FEM element type (solid, shell, beam, fluid)
*ELSET,ELSET=FemMaterialSolid
Evolumes

***********************************************************
** constraints fixed node sets
** ConstraintFixed
*NSET,NSET=ConstraintFixed
1,
2,
3,
4,
9,
10,
11,
12,
13,
14,
15,
16,
17,
18,
19,
20,
93,
94,
95,
96,
97,

** Physical constants for SI(mm) unit system with Kelvins
*PHYSICAL CONSTANTS, ABSOLUTE ZERO=0, STEFAN BOLTZMANN=5.670374419e-11

***********************************************************
** Materials
** see information about units at file end
** FreeCAD material name: CalculiX-Steel
** FemMaterial
*MATERIAL, NAME=FemMaterial
*ELASTIC
210000,0.3
*EXPANSION, ZERO=0
0

***********************************************************
** Sections
*SOLID SECTION, ELSET=FemMaterialSolid, MATERIAL=FemMaterial

***********************************************************
** At least one step is needed to run an CalculiX analysis of FreeCAD
*STEP, INC=2000
*STATIC


***********************************************************
** Fixed Constraints
** ConstraintFixed
*BOUNDARY
ConstraintFixed,1
ConstraintFixed,2
ConstraintFixed,3


***********************************************************
** constraints force node loads
** ConstraintForce
*CLOAD
** node loads on shape: Box:Face2
5,3,187500
6,3,187500
7,3,187500
8,3,187500
21,3,-750000
22,3,375000
23,3,-750000
24,3,-750000
25,3,375000
26,3,-750000
27,3,-750000
28,3,375000
29,3,-750000
30,3,-750000
31,3,375000
32,3,-750000
98,3,-1500000
99,3,-1500000
100,3,750000
101,3,-1500000
102,3,-1500000


***********************************************************
** Outputs --> frd file
*NODE FILE
U
*EL FILE
S, E
** outputs --> dat file
** reaction forces for Constraint fixed
*NODE PRINT, NSET=ConstraintFixed, TOTALS=ONLY
RF

*OUTPUT, FREQUENCY=1
***********************************************************
*END STEP

***********************************************************
** CalculiX Input file
**   written by    --> FreeCAD 0.21.0
**   written on    --> Tue Mar 28 04:39:55 2023
**   file name     --> CantilverHexa20FaceLoad.FCStd
**   analysis name --> Analysis
**
**
***********************************************************
**  About units:
**  See ccx manual, ccx does not know about any unit.
**  Golden rule: The user must make sure that the numbers they provide have consistent units.
**  The user is the FreeCAD calculix writer module ;-)
**
**  The unit system which is used at Guido Dhondt's company: mm, N, s, K
**  Since Length and Mass are connected by Force, if Length is mm the Mass is in t to get N
**  The following units are used to write to inp file:
**
**  Length: mm (this includes the mesh geometry)
**  Mass: t
**  TimeSpan: s
**  Temperature: K
**
**  This leads to:
**  Force: N
**  Pressure: N/mm^2 == MPa (Young's Modulus has unit Pressure)
**  Density: t/mm^3
**  Gravity: mm/s^2
**  Thermal conductivity: t*mm/K/s^3 == as W/m/K == kW/mm/K
**  Specific Heat: mm^2/s^2/K = J/kg/K == kJ/t/K
**
