** written by FreeCAD inp file writer for CalculiX,Abaqus meshes
** highest dimension mesh elements only.

** Nodes
*Node, NSET=Nall
1, 0, 0, 0
2, 0, 0, 1
3, 0, 5, 1
4, 0, 5, 0
5, 100, 0, 0
6, 100, 0, 1
7, 100, 5, 1
8, 100, 5, 0
9, 0, 0, 2
10, 0, 5, 2
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

** Volume elements
*Element, TYPE=C3D10, ELSET=Evolumes
1431, 1302, 7, 22, 525, 1313, 24, 1314, 2260, 530, 532
1432, 26, 525, 8, 1053, 533, 531, 28, 1064, 2261, 1065
1433, 1054, 4, 18, 514, 1058, 20, 1059, 2262, 519, 522
1434, 514, 1303, 3, 14, 2263, 1308, 520, 521, 1307, 16
1435, 1052, 5, 26, 524, 1061, 27, 1062, 2264, 526, 528
1436, 1301, 22, 6, 524, 1310, 23, 1311, 2265, 529, 527
1437, 225, 8, 775, 1053, 265, 818, 821, 1066, 1065, 2266
1438, 1302, 7, 775, 304, 1313, 819, 2267, 1315, 344, 820
1439, 513, 14, 2, 1300, 518, 15, 515, 2268, 1305, 1304
1440, 513, 1, 18, 1051, 516, 19, 517, 2269, 1056, 1055
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
** Define element set Eall
*ELSET, ELSET=Eall
Evolumes


***********************************************************
** Element sets for materials and FEM element type (solid, shell, beam, fluid)
*ELSET,ELSET=MaterialCopperSolid
1431,
1432,
1433,
1434,
1435,
1436,
1437,
1438,
1439,
1440,
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*ELSET,ELSET=MaterialInvarSolid
2181,
2182,
2183,
2184,
2185,
2186,
2187,
2188,
2189,
2190,
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
***********************************************************
** constraints fixed node sets
** ConstraintFixed
*NSET,NSET=ConstraintFixed
1,
2,
3,
4,
9,
10,
13,
14,
15,
16,
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
***********************************************************
** constraints temperature node sets
** ConstraintTemperatureHot
*NSET,NSET=ConstraintTemperatureHot
1,
4,
5,
8,
9,
10,
11,
12,
18,
19,
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** ConstraintTemperatureNormal
*NSET,NSET=ConstraintTemperatureNormal
1,
2,
3,
4,
9,
10,
13,
14,
15,
16,
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
***********************************************************
** constraints initial temperature node sets
** ConstraintInitialTemperature

** Physical constants for SI(mm) unit system with Kelvins
*PHYSICAL CONSTANTS, ABSOLUTE ZERO=0, STEFAN BOLTZMANN=5.670374419e-11

***********************************************************
** Materials
** see information about units at file end
** FreeCAD material name: Copper
** MaterialCopper
*MATERIAL, NAME=MaterialCopper
*ELASTIC
119000,0.343
*CONDUCTIVITY
398
*EXPANSION, ZERO=273
1.65E-05
*SPECIFIC HEAT
385000000
** FreeCAD material name: Invar
** MaterialInvar
*MATERIAL, NAME=MaterialInvar
*ELASTIC
140000,0.29
*CONDUCTIVITY
13.5
*EXPANSION, ZERO=273
1.25E-06
*SPECIFIC HEAT
515000000

***********************************************************
** Initial temperature constraint
*INITIAL CONDITIONS,TYPE=TEMPERATURE
** ConstraintInitialTemperature
Nall,273.0

***********************************************************
** Sections
*SOLID SECTION, ELSET=MaterialCopperSolid, MATERIAL=MaterialCopper
*SOLID SECTION, ELSET=MaterialInvarSolid, MATERIAL=MaterialInvar

***********************************************************
** At least one step is needed to run an CalculiX analysis of FreeCAD
*STEP, INC=2000
*COUPLED TEMPERATURE-DISPLACEMENT, STEADY STATE, SOLVER=SPOOLES
1.0,1.0,1e-05,1.0

***********************************************************
** Fixed Constraints
** ConstraintFixed
*BOUNDARY
ConstraintFixed,1
ConstraintFixed,2
ConstraintFixed,3


***********************************************************
** Fixed temperature constraint applied
** ConstraintTemperatureHot
*BOUNDARY
ConstraintTemperatureHot,11,11,373.0

** ConstraintTemperatureNormal
*BOUNDARY
ConstraintTemperatureNormal,11,11,273.0


***********************************************************
** Outputs --> frd file
*NODE FILE
U, NT
*EL FILE
S, E, HFL
** outputs --> dat file
** reaction forces for Constraint fixed
*NODE PRINT, NSET=ConstraintFixed, TOTALS=ONLY
RF

*OUTPUT, FREQUENCY=1
***********************************************************
*END STEP

***********************************************************
** CalculiX Input file
**   written by    --> FreeCAD 0.20.1
**   written on    --> Wed Aug 10 04:21:49 2022
**   file name     --> thermomech_bimetal.FCStd
**   analysis name --> Analysis
**
**
***********************************************************
**  About units:
**  See ccx manual, ccx does not know about any unit.
**  Golden rule: The user must make sure that the numbers they provide have consistent units.
**  The user is the FreeCAD calculix writer module ;-)
**
**  The unit system which is used at Guido Dhondt's company: mm, N, s, K
**  Since Length and Mass are connected by Force, if Length is mm the Mass is in t to get N
**  The following units are used to write to inp file:
**
**  Length: mm (this includes the mesh geometry)
**  Mass: t
**  TimeSpan: s
**  Temperature: K
**
**  This leads to:
**  Force: N
**  Pressure: N/mm^2 == MPa (Young's Modulus has unit Pressure)
**  Density: t/mm^3
**  Gravity: mm/s^2
**  Thermal conductivity: t*mm/K/s^3 == as W/m/K == kW/mm/K
**  Specific Heat: mm^2/s^2/K = J/kg/K == kJ/t/K
**
