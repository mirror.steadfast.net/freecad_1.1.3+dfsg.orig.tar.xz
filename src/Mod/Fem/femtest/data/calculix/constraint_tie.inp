** written by FreeCAD inp file writer for CalculiX,Abaqus meshes
** highest dimension mesh elements only.

** Nodes
*Node, NSET=Nall
1, 1235, 0, 1005
2, 0, 1235, 1005
3, 1.51e-13, -1235, 1005
4, 1234.811903518, -21.55372195005, 1005
5, 1099.832464672, -19.19764708101, 0
6, 1100, 0, 0
7, 1185, 0, 1005
8, 0, 1185, 1005
9, 1.45e-13, -1185, 1005
10, 1184.81951876, -20.68110162818, 1005
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

** Volume elements
*Element, TYPE=C3D10, ELSET=Evolumes
4623, 3, 1304, 89, 4537, 1595, 1596, 128, 4544, 8567, 4545
4624, 11, 4697, 4898, 587, 4702, 8568, 5773, 653, 4707, 5775
4625, 12, 4698, 523, 4896, 4704, 4708, 588, 5776, 8569, 5777
4626, 1, 4490, 13, 685, 4492, 4494, 32, 1588, 8570, 1587
4627, 4, 689, 147, 4628, 1601, 1600, 167, 4634, 8571, 4635
4628, 1283, 2, 52, 4536, 1592, 90, 1593, 8572, 4540, 4542
4629, 3, 4629, 129, 1009, 4630, 4632, 148, 1598, 8573, 1597
4630, 89, 1236, 88, 4539, 1775, 1774, 127, 4623, 8574, 4624
4631, 544, 4696, 5638, 543, 4757, 8575, 6086, 609, 4753, 6087
4632, 5693, 567, 4700, 566, 6156, 4812, 8576, 6155, 632, 4809
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
** Define element set Eall
*ELSET, ELSET=Eall
Evolumes


***********************************************************
** Element sets for materials and FEM element type (solid, shell, beam, fluid)
*ELSET,ELSET=MechanicalMaterialSolid
Evolumes

***********************************************************
** constraints fixed node sets
** ConstraintFixed
*NSET,NSET=ConstraintFixed
3,
9,
461,

***********************************************************
** constraints tie surface sets
** ConstraintTie
*SURFACE, NAME=TIE_DEPConstraintTie
4834,S1
4835,S1
4890,S1
4940,S1
5050,S1
5143,S1
6096,S1
6221,S1
6245,S1
6355,S1
6364,S1
6962,S1
7403,S1
7477,S1
7583,S1
7859,S1
8394,S1
8879,S1
9561,S1
9637,S1
9877,S1
10493,S2
*SURFACE, NAME=TIE_INDConstraintTie
4687,S4
5445,S3
5759,S4
6095,S1
6149,S4
6278,S4
6646,S1
6974,S4
7715,S3
7782,S1
7791,S4
7964,S2
8081,S1
8542,S3
8566,S2
8820,S1
8840,S4
9143,S4
9239,S3
9554,S1
9684,S1
10647,S2

** Physical constants for SI(mm) unit system with Kelvins
*PHYSICAL CONSTANTS, ABSOLUTE ZERO=0, STEFAN BOLTZMANN=5.670374419e-11

***********************************************************
** Materials
** see information about units at file end
** FreeCAD material name: Calculix-Steel
** MechanicalMaterial
*MATERIAL, NAME=MechanicalMaterial
*ELASTIC
210000,0.3
*EXPANSION, ZERO=0
0

***********************************************************
** Sections
*SOLID SECTION, ELSET=MechanicalMaterialSolid, MATERIAL=MechanicalMaterial

***********************************************************
** Tie Constraints
** ConstraintTie
*TIE, POSITION TOLERANCE=25, ADJUST=NO, NAME=TIEConstraintTie
TIE_DEPConstraintTie, TIE_INDConstraintTie

***********************************************************
** At least one step is needed to run an CalculiX analysis of FreeCAD
*STEP, INC=2000
*STATIC


***********************************************************
** Fixed Constraints
** ConstraintFixed
*BOUNDARY
ConstraintFixed,1
ConstraintFixed,2
ConstraintFixed,3


***********************************************************
** constraints force node loads
** ConstraintForce
*CLOAD
** node loads on shape: BooleanFragments:Edge2
2,2,1666.666666667
8,2,1666.666666667
385,2,6666.666666667


***********************************************************
** Outputs --> frd file
*NODE FILE
U
*EL FILE
S, E
** outputs --> dat file
** reaction forces for Constraint fixed
*NODE PRINT, NSET=ConstraintFixed, TOTALS=ONLY
RF

*OUTPUT, FREQUENCY=1
***********************************************************
*END STEP

***********************************************************
** CalculiX Input file
**   written by    --> FreeCAD 0.21.0
**   written on    --> Tue Mar 28 04:35:16 2023
**   file name     --> constraint_tie.FCStd
**   analysis name --> Analysis
**
**
***********************************************************
**  About units:
**  See ccx manual, ccx does not know about any unit.
**  Golden rule: The user must make sure that the numbers they provide have consistent units.
**  The user is the FreeCAD calculix writer module ;-)
**
**  The unit system which is used at Guido Dhondt's company: mm, N, s, K
**  Since Length and Mass are connected by Force, if Length is mm the Mass is in t to get N
**  The following units are used to write to inp file:
**
**  Length: mm (this includes the mesh geometry)
**  Mass: t
**  TimeSpan: s
**  Temperature: K
**
**  This leads to:
**  Force: N
**  Pressure: N/mm^2 == MPa (Young's Modulus has unit Pressure)
**  Density: t/mm^3
**  Gravity: mm/s^2
**  Thermal conductivity: t*mm/K/s^3 == as W/m/K == kW/mm/K
**  Specific Heat: mm^2/s^2/K = J/kg/K == kJ/t/K
**
