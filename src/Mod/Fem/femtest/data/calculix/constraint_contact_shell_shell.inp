** written by FreeCAD inp file writer for CalculiX,Abaqus meshes
** highest dimension mesh elements only.

** Nodes
*Node, NSET=Nall
1, 25, -6e-15, 500
2, 25, -6e-15, 0
3, 475, 76, 475
4, -25, 76, 475
5, 0, 76, 475
6, 24.51963201008, 4.877258050403, 500
7, 23.09698831278, 9.567085809127, 500
8, 20.78674030756, 13.88925582549, 500
9, 17.67766952966, 17.67766952966, 500
10, 13.88925582549, 20.78674030756, 500
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

** Face elements
*Element, TYPE=S3, ELSET=Efaces
329, 327, 329, 328
330, 330, 332, 331
331, 333, 335, 334
332, 336, 338, 337
333, 339, 341, 340
334, 342, 344, 343
335, 345, 347, 346
336, 348, 350, 349
337, 331, 332, 351
338, 352, 354, 353
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
** Define element set Eall
*ELSET, ELSET=Eall
Efaces


***********************************************************
** Element sets for materials and FEM element type (solid, shell, beam, fluid)
*ELSET,ELSET=MechanicalMaterialShellThickness
Efaces

***********************************************************
** constraints displacement node sets
** ConstraintDisplacement
*NSET,NSET=ConstraintDisplacement
2,
3,
136,
137,
138,
139,
140,
141,
142,
143,
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
***********************************************************
** constraints contact surface sets
** ConstraintContact
*SURFACE, NAME=DEPConstraintContact
329,S2
330,S2
331,S2
332,S2
333,S2
334,S2
335,S2
336,S2
337,S2
338,S2
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*SURFACE, NAME=INDConstraintContact
7827,S2
7828,S2
7829,S2
7830,S2
7831,S2
7832,S2
7833,S2
7834,S2
7835,S2
7836,S2
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
** Physical constants for SI(mm) unit system with Kelvins
*PHYSICAL CONSTANTS, ABSOLUTE ZERO=0, STEFAN BOLTZMANN=5.670374419e-11

***********************************************************
** Materials
** see information about units at file end
** FreeCAD material name: AlCuMgPb
** MechanicalMaterial
*MATERIAL, NAME=MechanicalMaterial
*ELASTIC
72000,0.3
*EXPANSION, ZERO=0
0

***********************************************************
** Sections
*SHELL SECTION, ELSET=MechanicalMaterialShellThickness, MATERIAL=MechanicalMaterial, OFFSET=0
0.5

***********************************************************
** Contact Constraints
** ConstraintContact
*CONTACT PAIR, INTERACTION=INTConstraintContact, TYPE=SURFACE TO SURFACE
DEPConstraintContact, INDConstraintContact
*SURFACE INTERACTION, NAME=INTConstraintContact
*SURFACE BEHAVIOR, PRESSURE-OVERCLOSURE=LINEAR
1000000

***********************************************************
** At least one step is needed to run an CalculiX analysis of FreeCAD
*STEP, INC=2000
*STATIC


***********************************************************
** Displacement constraint applied
** ConstraintDisplacement
*BOUNDARY
ConstraintDisplacement,1,1,0.0
ConstraintDisplacement,2,2,0.0
ConstraintDisplacement,3,3,0.0


***********************************************************
** constraints force node loads
** ConstraintForce
*CLOAD
** node load on shape: Load_place_point:Vertex1
5,2,-5000


***********************************************************
** Outputs --> frd file
*NODE FILE, OUTPUT=3d
U
*EL FILE
S, E
** outputs --> dat file
** reaction forces for Constraint displacement constraining translation
*NODE PRINT, NSET=ConstraintDisplacement, TOTALS=ONLY
RF
** contact forces for Constraint contact
*CONTACT PRINT, MASTER=INDConstraintContact, SLAVE=DEPConstraintContact
CF, CFN, CFS

*OUTPUT, FREQUENCY=1
***********************************************************
*END STEP

***********************************************************
** CalculiX Input file
**   written by    --> FreeCAD 0.21.0
**   written on    --> Tue Mar 28 05:18:47 2023
**   file name     --> Contact_Shell_Shell.FCStd
**   analysis name --> Analysis
**
**
***********************************************************
**  About units:
**  See ccx manual, ccx does not know about any unit.
**  Golden rule: The user must make sure that the numbers they provide have consistent units.
**  The user is the FreeCAD calculix writer module ;-)
**
**  The unit system which is used at Guido Dhondt's company: mm, N, s, K
**  Since Length and Mass are connected by Force, if Length is mm the Mass is in t to get N
**  The following units are used to write to inp file:
**
**  Length: mm (this includes the mesh geometry)
**  Mass: t
**  TimeSpan: s
**  Temperature: K
**
**  This leads to:
**  Force: N
**  Pressure: N/mm^2 == MPa (Young's Modulus has unit Pressure)
**  Density: t/mm^3
**  Gravity: mm/s^2
**  Thermal conductivity: t*mm/K/s^3 == as W/m/K == kW/mm/K
**  Specific Heat: mm^2/s^2/K = J/kg/K == kJ/t/K
**
