** written by FreeCAD inp file writer for CalculiX,Abaqus meshes
** highest dimension mesh elements only.

** Nodes
*Node, NSET=Nall
1, 4, -9.797174393179e-16, 0
2, 4, -9.797174393179e-16, 50
3, 5, -1.224646799147e-15, 0
4, 5, -1.224646799147e-15, 50
5, 4, -9.797174393179e-16, 1.8
6, 4, -9.797174393179e-16, 3.65
7, 4, -9.797174393179e-16, 5.45
8, 4, -9.797174393179e-16, 7.15
9, 4, -9.797174393179e-16, 9
10, 4, -9.797174393179e-16, 10.85
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

** Volume elements
*Element, TYPE=C3D10, ELSET=Evolumes
2085, 188, 242, 501, 168, 1521, 3935, 3936, 1337, 1471, 3937
2086, 25, 526, 26, 137, 3938, 3939, 1007, 1165, 3940, 1166
2087, 279, 210, 280, 678, 1603, 1605, 1607, 3942, 3941, 3943
2088, 786, 769, 270, 715, 3280, 3944, 3945, 3279, 3225, 3946
2089, 562, 114, 115, 29, 2575, 1101, 2576, 3948, 3947, 3949
2090, 694, 293, 744, 743, 3950, 3951, 3147, 3145, 3952, 3149
2091, 114, 562, 561, 186, 2575, 2577, 2573, 3954, 3953, 3955
2092, 529, 115, 30, 116, 2483, 3956, 3957, 2482, 1102, 3958
2093, 672, 272, 203, 673, 3959, 1582, 3961, 2933, 3960, 3962
2094, 796, 841, 336, 795, 3459, 3963, 3964, 3405, 3460, 3965
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
** Define element set Eall
*ELSET, ELSET=Eall
Evolumes


***********************************************************
** Element sets for materials and FEM element type (solid, shell, beam, fluid)
*ELSET,ELSET=MechanicalMaterialSolid
Evolumes

***********************************************************
** constraints fixed node sets
** ConstraintFixed
*NSET,NSET=ConstraintFixed
2,
4,
45,
46,
47,
48,
49,
50,
51,
52,
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
***********************************************************
** constraints transform node sets
** ConstraintTransform
*NSET,NSET=CylinConstraintTransform
3,
4,
58,
59,
60,
61,
62,
63,
64,
65,
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
** Physical constants for SI(mm) unit system with Kelvins
*PHYSICAL CONSTANTS, ABSOLUTE ZERO=0, STEFAN BOLTZMANN=5.670374419e-11

***********************************************************
** Materials
** see information about units at file end
** FreeCAD material name: Calculix-Steel
** MechanicalMaterial
*MATERIAL, NAME=MechanicalMaterial
*ELASTIC
210000,0.3
*EXPANSION, ZERO=0
0

***********************************************************
** Sections
*SOLID SECTION, ELSET=MechanicalMaterialSolid, MATERIAL=MechanicalMaterial

***********************************************************
** Transform Constraints
** ConstraintTransform
*TRANSFORM, NSET=CylinConstraintTransform, TYPE=C
0,0,25,0,0,24

***********************************************************
** At least one step is needed to run an CalculiX analysis of FreeCAD
*STEP, INC=2000
*STATIC


***********************************************************
** Fixed Constraints
** ConstraintFixed
*BOUNDARY
ConstraintFixed,1
ConstraintFixed,2
ConstraintFixed,3


***********************************************************
** constraints force node loads
** ConstraintForce
*CLOAD
** node loads on shape: Cut:Face1
3,2,-0
4,2,-0
58,2,-0
59,2,-0
60,2,-0
61,2,-0
62,2,-0
63,2,-0
64,2,-0
65,2,-0
66,2,-0
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

***********************************************************
** Outputs --> frd file
*NODE FILE
U
*EL FILE
S, E
** outputs --> dat file
** reaction forces for Constraint fixed
*NODE PRINT, NSET=ConstraintFixed, TOTALS=ONLY
RF

*OUTPUT, FREQUENCY=1
***********************************************************
*END STEP

***********************************************************
** CalculiX Input file
**   written by    --> FreeCAD 0.21.0
**   written on    --> Tue Mar 28 05:30:48 2023
**   file name     --> constraint_transform_torque.FCStd
**   analysis name --> Analysis
**
**
***********************************************************
**  About units:
**  See ccx manual, ccx does not know about any unit.
**  Golden rule: The user must make sure that the numbers they provide have consistent units.
**  The user is the FreeCAD calculix writer module ;-)
**
**  The unit system which is used at Guido Dhondt's company: mm, N, s, K
**  Since Length and Mass are connected by Force, if Length is mm the Mass is in t to get N
**  The following units are used to write to inp file:
**
**  Length: mm (this includes the mesh geometry)
**  Mass: t
**  TimeSpan: s
**  Temperature: K
**
**  This leads to:
**  Force: N
**  Pressure: N/mm^2 == MPa (Young's Modulus has unit Pressure)
**  Density: t/mm^3
**  Gravity: mm/s^2
**  Thermal conductivity: t*mm/K/s^3 == as W/m/K == kW/mm/K
**  Specific Heat: mm^2/s^2/K = J/kg/K == kJ/t/K
**
