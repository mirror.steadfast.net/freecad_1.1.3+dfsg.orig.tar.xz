** written by FreeCAD inp file writer for CalculiX,Abaqus meshes
** highest dimension mesh elements only.

** Nodes
*Node, NSET=Nall
1, 67, -1.776356838198e-15, -15
2, 67, -1.776356838198e-15, 15
3, 47, 0, -15
4, 47, 0, 15
5, 42.69003028349, 41.23803861626, -15
6, 42.69003028349, 41.23803861626, 15
7, 34.63800439591, 31.76804450181, -15
8, 34.63800439591, 31.76804450181, 15
9, -105, 5.329070518201e-15, -15
10, -105, 5.329070518201e-15, 15
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

** Volume elements
*Element, TYPE=C3D10, ELSET=Evolumes
807, 329, 326, 230, 406, 348, 1370, 1371, 1373, 1372, 1374
808, 327, 324, 259, 264, 372, 1375, 1376, 1378, 1377, 316
809, 328, 331, 59, 437, 359, 357, 341, 1380, 1379, 448
810, 329, 324, 259, 327, 374, 1375, 1381, 349, 372, 1376
811, 437, 331, 59, 436, 1379, 357, 448, 451, 1382, 453
812, 321, 264, 327, 376, 1383, 1378, 368, 1385, 1384, 1386
813, 410, 230, 326, 406, 1388, 1370, 1387, 421, 1374, 1372
814, 329, 230, 262, 406, 1371, 1389, 1390, 1373, 1374, 1391
815, 229, 327, 262, 264, 1394, 1392, 1393, 1395, 1378, 317
816, 408, 257, 328, 256, 1398, 1396, 1397, 1399, 308, 1400
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
** Define element set Eall
*ELSET, ELSET=Eall
Evolumes


***********************************************************
** Element sets for materials and FEM element type (solid, shell, beam, fluid)
*ELSET,ELSET=MaterialSolid
Evolumes

***********************************************************
** constraints fixed node sets
** ConstraintFixed
*NSET,NSET=ConstraintFixed
9,
10,
11,
12,
114,
115,
116,
117,
118,
179,
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
***********************************************************
** constraints sectionprint surface sets
** ConstraintSectionPrint
*SURFACE, NAME=SECTIONFACEConstraintSectionPrint
811,S4
872,S2
880,S1
921,S4
938,S1
944,S1
950,S1
952,S4
960,S3
961,S4
963,S1
965,S3
967,S4
971,S4
1417,S4
1698,S4
1741,S4
1763,S1
1781,S1
1788,S1
1792,S1
1795,S1
1799,S1
1800,S1
1802,S1
1816,S3
1819,S4
1823,S4

** Physical constants for SI(mm) unit system with Kelvins
*PHYSICAL CONSTANTS, ABSOLUTE ZERO=0, STEFAN BOLTZMANN=5.670374419e-11

***********************************************************
** Materials
** see information about units at file end
** FreeCAD material name: CalculiX-Steel
** Material
*MATERIAL, NAME=Material
*ELASTIC
210000,0.3
*EXPANSION, ZERO=0
0

***********************************************************
** Sections
*SOLID SECTION, ELSET=MaterialSolid, MATERIAL=Material

***********************************************************
** At least one step is needed to run an CalculiX analysis of FreeCAD
*STEP, INC=2000
*STATIC


***********************************************************
** Fixed Constraints
** ConstraintFixed
*BOUNDARY
ConstraintFixed,1
ConstraintFixed,2
ConstraintFixed,3


***********************************************************
** SectionPrint Constraints
** ConstraintSectionPrint
*SECTION PRINT, SURFACE=SECTIONFACEConstraintSectionPrint, NAME=SECTIONPRINTConstraintSectionPrint
SOF, SOM, SOAREA

***********************************************************
** constraints pressure element face loads
** ConstraintPressure
*DLOAD
** BooleanFragments.Face1
846,P3,100.0
861,P1,100.0
875,P4,100.0
883,P3,100.0
887,P1,100.0
888,P1,100.0
903,P1,100.0
929,P4,100.0
933,P3,100.0
936,P1,100.0
937,P1,100.0
940,P1,100.0
941,P1,100.0
946,P4,100.0
949,P2,100.0
951,P4,100.0
954,P3,100.0
955,P4,100.0

***********************************************************
** Outputs --> frd file
*NODE FILE
U
*EL FILE
S, E
** outputs --> dat file
** reaction forces for Constraint fixed
*NODE PRINT, NSET=ConstraintFixed, TOTALS=ONLY
RF

*OUTPUT, FREQUENCY=1
***********************************************************
*END STEP

***********************************************************
** CalculiX Input file
**   written by    --> FreeCAD 0.21.0
**   written on    --> Tue Mar 28 06:49:11 2023
**   file name     --> constraint_sectionprint.FCStd
**   analysis name --> Analysis
**
**
***********************************************************
**  About units:
**  See ccx manual, ccx does not know about any unit.
**  Golden rule: The user must make sure that the numbers they provide have consistent units.
**  The user is the FreeCAD calculix writer module ;-)
**
**  The unit system which is used at Guido Dhondt's company: mm, N, s, K
**  Since Length and Mass are connected by Force, if Length is mm the Mass is in t to get N
**  The following units are used to write to inp file:
**
**  Length: mm (this includes the mesh geometry)
**  Mass: t
**  TimeSpan: s
**  Temperature: K
**
**  This leads to:
**  Force: N
**  Pressure: N/mm^2 == MPa (Young's Modulus has unit Pressure)
**  Density: t/mm^3
**  Gravity: mm/s^2
**  Thermal conductivity: t*mm/K/s^3 == as W/m/K == kW/mm/K
**  Specific Heat: mm^2/s^2/K = J/kg/K == kJ/t/K
**
