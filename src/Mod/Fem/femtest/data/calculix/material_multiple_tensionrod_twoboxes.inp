** written by FreeCAD inp file writer for CalculiX,Abaqus meshes
** highest dimension mesh elements only.

** Nodes
*Node, NSET=Nall
1, 0, 0, 10
2, 0, 0, 20
3, 0, 10, 10
4, 0, 10, 20
5, 10, 0, 10
6, 10, 0, 20
7, 10, 10, 10
8, 10, 10, 20
9, 0, 0, 0
10, 0, 10, 0
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

** Volume elements
*Element, TYPE=C3D10, ELSET=Evolumes
1, 177, 73, 173, 348, 350, 349, 196, 352, 351, 353
2, 148, 177, 173, 348, 355, 196, 354, 356, 352, 353
3, 124, 73, 123, 348, 358, 357, 144, 359, 351, 360
4, 173, 124, 123, 348, 362, 144, 361, 353, 359, 360
5, 73, 77, 148, 348, 97, 363, 364, 351, 365, 356
6, 173, 176, 148, 348, 197, 366, 354, 353, 367, 356
7, 198, 176, 173, 348, 369, 197, 368, 370, 367, 353
8, 175, 198, 173, 348, 371, 368, 195, 372, 370, 353
9, 175, 173, 123, 348, 195, 361, 373, 372, 353, 360
10, 98, 102, 148, 348, 122, 374, 375, 377, 376, 356
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
** Define element set Eall
*ELSET, ELSET=Eall
Evolumes


***********************************************************
** Element sets for materials and FEM element type (solid, shell, beam, fluid)
*ELSET,ELSET=MechanicalMaterialLowSolid
149,
150,
151,
152,
153,
154,
155,
156,
157,
158,
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*ELSET,ELSET=MechanicalMaterialUppSolid
1,
2,
3,
4,
5,
6,
7,
8,
9,
10,
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
***********************************************************
** constraints fixed node sets
** ConstraintFixed
*NSET,NSET=ConstraintFixed
9,
10,
11,
12,
52,
53,
54,
58,
59,
60,
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
** Physical constants for SI(mm) unit system with Kelvins
*PHYSICAL CONSTANTS, ABSOLUTE ZERO=0, STEFAN BOLTZMANN=5.670374419e-11

***********************************************************
** Materials
** see information about units at file end
** FreeCAD material name: Aluminium-Generic
** MechanicalMaterialLow
*MATERIAL, NAME=MechanicalMaterialLow
*ELASTIC
70000,0.35
*EXPANSION, ZERO=0
0
** FreeCAD material name: Steel-Generic
** MechanicalMaterialUpp
*MATERIAL, NAME=MechanicalMaterialUpp
*ELASTIC
200000,0.3
*EXPANSION, ZERO=0
0

***********************************************************
** Sections
*SOLID SECTION, ELSET=MechanicalMaterialLowSolid, MATERIAL=MechanicalMaterialLow
*SOLID SECTION, ELSET=MechanicalMaterialUppSolid, MATERIAL=MechanicalMaterialUpp

***********************************************************
** At least one step is needed to run an CalculiX analysis of FreeCAD
*STEP, INC=2000
*STATIC


***********************************************************
** Fixed Constraints
** ConstraintFixed
*BOUNDARY
ConstraintFixed,1
ConstraintFixed,2
ConstraintFixed,3


***********************************************************
** constraints pressure element face loads
** ConstraintPressure
*DLOAD
** MultiMatCompSolid.Face11
61,P3,1000.0
74,P3,1000.0
75,P3,1000.0
80,P2,1000.0
96,P3,1000.0
99,P3,1000.0
100,P4,1000.0
102,P3,1000.0
117,P3,1000.0
118,P3,1000.0
121,P3,1000.0
124,P4,1000.0
127,P2,1000.0
131,P4,1000.0
132,P4,1000.0
134,P2,1000.0

***********************************************************
** Outputs --> frd file
*NODE FILE
U
*EL FILE
S, E
** outputs --> dat file
** reaction forces for Constraint fixed
*NODE PRINT, NSET=ConstraintFixed, TOTALS=ONLY
RF

*OUTPUT, FREQUENCY=1
***********************************************************
*END STEP

***********************************************************
** CalculiX Input file
**   written by    --> FreeCAD 0.21.0
**   written on    --> Tue Mar 28 06:48:16 2023
**   file name     --> material_multiple_tensionrod_twoboxes.FCStd
**   analysis name --> Analysis
**
**
***********************************************************
**  About units:
**  See ccx manual, ccx does not know about any unit.
**  Golden rule: The user must make sure that the numbers they provide have consistent units.
**  The user is the FreeCAD calculix writer module ;-)
**
**  The unit system which is used at Guido Dhondt's company: mm, N, s, K
**  Since Length and Mass are connected by Force, if Length is mm the Mass is in t to get N
**  The following units are used to write to inp file:
**
**  Length: mm (this includes the mesh geometry)
**  Mass: t
**  TimeSpan: s
**  Temperature: K
**
**  This leads to:
**  Force: N
**  Pressure: N/mm^2 == MPa (Young's Modulus has unit Pressure)
**  Density: t/mm^3
**  Gravity: mm/s^2
**  Thermal conductivity: t*mm/K/s^3 == as W/m/K == kW/mm/K
**  Specific Heat: mm^2/s^2/K = J/kg/K == kJ/t/K
**
