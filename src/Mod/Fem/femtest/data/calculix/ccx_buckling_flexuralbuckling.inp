** written by FreeCAD inp file writer for CalculiX,Abaqus meshes
** highest dimension mesh elements only.

** Nodes
*Node, NSET=Nall
1, 0, 1.5, 0
2, 0, 1.5, 0.5
3, 0, 1.125, 0.5
4, 0, 1.125, 0
5, 0.25, 1.5, 0
6, 0.25, 1.5, 0.5
7, 0.25, 1.125, 0.5
8, 0.25, 1.125, 0
9, 0, 1.5, 1
10, 0, 1.125, 1
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

** Volume elements
*Element, TYPE=C3D8, ELSET=Evolumes
1, 3, 4, 1, 2, 7, 8, 5, 6
2, 10, 3, 2, 9, 12, 7, 6, 11
3, 14, 10, 9, 13, 16, 12, 11, 15
4, 18, 14, 13, 17, 20, 16, 15, 19
5, 22, 18, 17, 21, 24, 20, 19, 23
6, 26, 22, 21, 25, 28, 24, 23, 27
7, 30, 26, 25, 29, 32, 28, 27, 31
8, 34, 30, 29, 33, 36, 32, 31, 35
9, 38, 34, 33, 37, 40, 36, 35, 39
10, 42, 38, 37, 41, 44, 40, 39, 43
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
** Define element set Eall
*ELSET, ELSET=Eall
Evolumes


***********************************************************
** Element sets for materials and FEM element type (solid, shell, beam, fluid)
*ELSET,ELSET=MechanicalMaterialSolid
Evolumes

***********************************************************
** constraints fixed node sets
** ConstraintFixed
*NSET,NSET=ConstraintFixed
1,
4,
5,
8,
69,
72,
103,
106,
137,
140,
172,
174,
206,
223,
240,
257,
259,
291,
308,
325,
342,
344,
376,
393,
410,

** Physical constants for SI(mm) unit system with Kelvins
*PHYSICAL CONSTANTS, ABSOLUTE ZERO=0, STEFAN BOLTZMANN=5.670374419e-11

***********************************************************
** Materials
** see information about units at file end
** FreeCAD material name: CalculiX-Steel
** MechanicalMaterial
*MATERIAL, NAME=MechanicalMaterial
*ELASTIC
210000,0.3

***********************************************************
** Sections
*SOLID SECTION, ELSET=MechanicalMaterialSolid, MATERIAL=MechanicalMaterial

***********************************************************
** At least one step is needed to run an CalculiX analysis of FreeCAD
*STEP
*BUCKLE
10,0.01

***********************************************************
** Fixed Constraints
** ConstraintFixed
*BOUNDARY
ConstraintFixed,1
ConstraintFixed,2
ConstraintFixed,3


***********************************************************
** constraints force node loads
** ConstraintForce
*CLOAD
** node loads on shape: Beam:Face6
65,3,-0.328125
66,3,-0.65625
67,3,-0.65625
68,3,-1.3125
101,3,-0.65625
102,3,-1.3125
135,3,-0.65625
136,3,-1.3125
169,3,-0.328125
170,3,-0.65625
203,3,-0.65625
204,3,-1.3125
221,3,-1.3125
238,3,-1.3125
255,3,-0.65625
288,3,-0.65625
289,3,-1.3125
306,3,-1.3125
323,3,-1.3125
340,3,-0.65625
373,3,-0.328125
374,3,-0.65625
391,3,-0.65625
408,3,-0.65625
425,3,-0.328125


***********************************************************
** Outputs --> frd file
*NODE FILE
U
*EL FILE
S, E
** outputs --> dat file
** reaction forces for Constraint fixed
*NODE PRINT, NSET=ConstraintFixed, TOTALS=ONLY
RF

*OUTPUT, FREQUENCY=1
***********************************************************
*END STEP

***********************************************************
** CalculiX Input file
**   written by    --> FreeCAD 0.21.0
**   written on    --> Tue Mar 28 03:37:15 2023
**   file name     --> ccx_buckling_flexuralbuckling.FCStd
**   analysis name --> Analysis
**
**
***********************************************************
**  About units:
**  See ccx manual, ccx does not know about any unit.
**  Golden rule: The user must make sure that the numbers they provide have consistent units.
**  The user is the FreeCAD calculix writer module ;-)
**
**  The unit system which is used at Guido Dhondt's company: mm, N, s, K
**  Since Length and Mass are connected by Force, if Length is mm the Mass is in t to get N
**  The following units are used to write to inp file:
**
**  Length: mm (this includes the mesh geometry)
**  Mass: t
**  TimeSpan: s
**  Temperature: K
**
**  This leads to:
**  Force: N
**  Pressure: N/mm^2 == MPa (Young's Modulus has unit Pressure)
**  Density: t/mm^3
**  Gravity: mm/s^2
**  Thermal conductivity: t*mm/K/s^3 == as W/m/K == kW/mm/K
**  Specific Heat: mm^2/s^2/K = J/kg/K == kJ/t/K
**
